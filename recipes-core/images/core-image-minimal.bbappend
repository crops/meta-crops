inherit populate_sdk_with_json
